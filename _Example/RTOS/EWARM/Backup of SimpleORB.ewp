# IAR project Backup of SimpleORB.ewp, settings and files
configuration SimpleORB (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32H5xx_Nucleo; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../../../Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SimpleORB.hex
  ILINK.IlinkOutputFile: SimpleORB.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_freertos.c stm32h5xx_it.c stm32h5xx_hal_msp.c task_publisher.c task_subscriber_serial.c task_subscriber_led.c
    ../../../Src/: simple_orb.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: portasm.s port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
